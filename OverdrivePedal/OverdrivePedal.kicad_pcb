# Repository cracked-machine/BoostFXPedalWithFadingLED_HW

File README.md:

## Boost Pedal with LEDs

- Required Kicad Hardware library: https://github.com/cracked-machine/KicadLibrary
- Related SW project: https://github.com/cracked-machine/BoostFXPedalWithFadingLED__SW

This is a simple opamp-based gain boost circuit for guitar FX pedal.

The sockets and switches are wired directly to the board, they are not panel-mounted. This makes the design simpler but construction becomes more time-consuming. Mechanical layout for the enclosure is below.

This design went through several revisions.

- RevA is a purely analog HW design without any LEDs.
- RevC added a micro-controller to run 8 SMT LEDs in a fading pattern using PWM. RevC uses multiple SPST solid-state switches (DG467) to simplify the footswitch control and replace the bulky and expensive 3PDT mechanical switches often used in guitar FX pedals. Some high frequency signal attenuation could be heard with the DG467 switches. This is probably due to the MOSFET capacitance of the DG467 switches. However, [FFT analysis](OverdrivePedal_RevC/OverDriveSpectrumAnalysis) was inconclusive.
- RevD proposes a design to use a single DPDT Relay to avoid any signal loss issues. However, this revision was not constructed/tested.

Revision|Comments|Schema|Front|Back
:--------:|:--:|:--:|:--:|:---:
RevA|Without LEDs|[link](OverdrivePedal/docs/OverdrivePedal.pdf)|||
RevC|With LEDs, SPST SolidState|[link](OverdrivePedal_RevC/docs/OverdrivePedal_RevC.pdf)|||
RevD|With LEDs, DPDT Relay|[link](OverdrivePedal_RevD/docs/OverdrivePedal_RevD.pdf)|||

### Demo of RevC

## KiCad design OverdrivePedal/OverdrivePedal.kicad_pcb

Parts:
J1, J2, J6: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J3, J4, J5: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
R1: 22M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 2K7; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: TL072; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: U1.8 (V+); also elsewhere on the board
-5V: U1.4 (V-); also elsewhere on the board
/PosNeg5V_PSU/+9V_IN: J2.1; also elsewhere on the board
GNDS: J1.2, J2.2, J6.2, R1.2, R2.2, R3.2; also elsewhere on the board
unnamed: J1.1, J3.2
unnamed: J3.1, R1.1, U1.3 (+)
unnamed: J3.3, J5.1
unnamed: J4.1, J5.3, R3.1, U1.7
unnamed: J4.2, J4.3, R2.1, U1.6 (-)
unnamed: J5.2, J6.1
unnamed: U1.1, U1.2 (-), U1.5 (+)

Notes on the sheet:
GAIN POT
Output Jack
1 Half DPDT FootSwitch

Parts:
C3, C6: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C7: 1uF; CP_Elec_4x5.7
C8: 2.2uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C9: 10uF; CP_Elec_4x5.7
C10, C11: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: D_Schottky; D_SOD-123F
R5, R8: 330R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6, R7: 1K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U3: MIC5233YM5; SOT-23-5_HandSoldering
U4: MIC5270YM5; SOT-23-5_HandSoldering

Connections:
+5V: C8.1, C10.1, R7.1, U3.5 (OUT); also elsewhere on the board
-5V: C9.2, C11.1, R8.1, U4.4 (-OUT); also elsewhere on the board
/PosNeg5V_PSU/+9V_IN: D1.2 (A); also elsewhere on the board
/PosNeg5V_PSU/+9V_POL: C3.1, C6.1, D1.1 (K), U3.1 (IN), U3.3 (EN); also elsewhere on the board
/PosNeg5V_PSU/-9V_POL: C7.2, U4.5 (-IN); also elsewhere on the board
GNDS: C3.2, C6.2, C7.1, C8.2, C9.1, C10.2, C11.2, R5.2, R6.2, U3.2 (GND), U4.2 (GND); also elsewhere on the board
unnamed: R5.1, R7.2, U3.4 (ADJ)
unnamed: R6.1, R8.2, U4.3 (ADJ)

Board: 2 copper layers, 31.8 x 43.8 mm, 27 parts (6 on the bottom side), 17 nets.

Other parts of the board:
C4, C5: 10uF; CP_Elec_4x5.7
U2: TC7662Bx0A; SOIC-8_3.9x4.9mm_P1.27mm

Their connections:
/PosNeg5V_PSU/+9V_POL: U2.1, U2.8; also elsewhere on the board
/PosNeg5V_PSU/-9V_POL: C5.2, U2.5; also elsewhere on the board
GNDS: C5.1, U2.3; also elsewhere on the board
unnamed: C4.1, U2.2
unnamed: C4.2, U2.4

## KiCad design OverdrivePedal_RevC/OverdrivePedal_RevC.kicad_pcb

Board: 2 copper layers, 42.5 x 30.5 mm, 57 parts (0 on the bottom side), 34 nets.

Parts:
C1, C2, C11, C12: 10uF; C_0402_1005Metric
C3, C4, C5, C13: 1uF; C_0402_1005Metric
C6, C7, C9, C17: 100nF; C_0402_1005Metric
C8, C10: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C14, C15: 1u; C_0402_1005Metric
D1: B0520LW-RH; D_SOD-123F
D2, D3, D4, D5, D6, D7, D8, D9: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1, J6: AudioJack2-Connector; PinSocket_1x02_P2.54mm_Vertical
J2: Barrel_Jack; PinHeader_1x02_P2.54mm_Vertical
J3: Conn_01x05; PinHeader_1x05_P1.27mm_Vertical
J4: SW_SPST; PinSocket_1x02_P2.54mm_Vertical
R1, R3: 10M; R_0402_1005Metric
R2: 2K7; R_0402_1005Metric
R6, R8, R10, R11: 10K; R_0402_1005Metric
R7: 100R; R_0402_1005Metric
RV1: B10K; PinHeader_1x03_P2.54mm_Vertical
RV2: B10K; Potentiometer_Vishay_T73XW_Horizontal
TP1, TP2, TP3, TP4, TP5, TP6, TP7: TestPoint; TestPoint_Pad_1.0x1.0mm
U1, U4, U6: DG468DV_T1_E3; TSOP-6_1.65x3.05mm_P0.95mm
U2: TL071; SOIC-8_3.9x4.9mm_P1.27mm
U3: TPS60400; SOT-23-5_HandSoldering
U5: STM32L011D4Px; TSSOP-14_4.4x5mm_P0.65mm
U7: SE8233X2; SOT-23
U8: SE8250X2; SOT-23
U9, U10: PAM2812; TSOT-23-6_HandSoldering

Connections:
+3V3: C9.1, C11.1, J3.1, R11.1, RV2.3, TP6.1, U5.10, U7.2
+5V: C4.1, C6.1, C12.1, C14.1, C15.1, D2.2, D3.2, D4.2, D5.2, D6.2, D7.2, D8.2, D9.2, TP5.1, U1.5, U2.7, U3.2, U4.5, U6.5, U8.2
-5V: C7.1, C13.1, R7.2, TP7.1, U1.2, U2.4, U4.2, U6.2
/CLEAN_ENABLE: R10.1, TP1.1, U4.3, U5.2
/FX_ENABLE: R8.1, TP4.1, U1.3, U5.11, U6.3
/GPIO_EXTI4_BYPASS: J4.2, U5.7
/PosNeg5V_PSU/+9V_IN: D1.2, J2.2
/PosNeg5V_PSU/+9V_POL: C8.1, C10.1, D1.1, U7.3, U8.3
/SYS_NRST: C17.2, J3.5, U5.4
/SYS_SWCLK: J3.2, U5.14
/SYS_SWDIO: J3.4, U5.13
/TIM2_CH1_PWM: TP3.1, U5.5, U10.1
/TIM2_CH2_PWM: TP2.1, U5.6, U9.1
GNDS: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C17.1, J1.2, J2.1, J3.3, J4.1, J6.2, R1.2, R2.2, R3.2, R6.1, R8.2, R10.2, RV2.1, U1.4, U3.4, U4.4, U5.9, U6.4, U7.1, U8.1, U9.2, U10.2
unnamed: C1.1, R1.1, U2.3
unnamed: C1.2, U1.6
unnamed: C2.1, R3.1, U6.1
unnamed: C2.2, U2.6
unnamed: C3.1, U3.3
unnamed: C3.2, U3.5
unnamed: C5.1, R7.1, U3.1
unnamed: D2.1, U9.6
unnamed: D3.1, U10.6
unnamed: D4.1, U9.5
unnamed: D5.1, U10.5
unnamed: D6.1, U9.4
unnamed: D7.1, U10.4
unnamed: D8.1, U9.3
unnamed: D9.1, U10.3
unnamed: J1.1, U1.1, U4.1
unnamed: J6.1, U4.6, U6.6
unnamed: R2.1, RV1.1, RV1.2, U2.2
unnamed: R6.2, R11.2, U5.1
unnamed: RV2.2, U5.8

## Commit log

2020-03-04 First Schema design
2020-03-04 RevA Layout completed
2020-03-08 Replaced TL071 with TL072
    UPDATED LAYOUT
2020-03-09 Tested RevA Layout
    - Removed AC coupling caps
    - Reversed Switch connector
2020-03-10 RevB Layout completed
2020-03-10 modified RevB
2020-03-18 Added 2 x RGB LEDS
2020-03-20 Added gnd plane revb
2020-03-27 updated revb
2020-03-27 Added extra leds
2020-03-28 updated revb design
    - Added solidstate ICs for bypass switching to allow for mom. footswitch
    - Added STM32L011 MCU
    - Added SE82XX (SOT23) LDOs for 5V and 3V3 rails
2020-03-29 Draft layout completed
    RevB layout
2020-03-29 updated draft
2020-03-31 RevB layout gerbers submitted
2020-04-11 updated revc
    - Switch PC15 to PA9 for FX_ENABLE
    - connected BOOT0 to GND
    - Removed U11 charge pump (not required/causing oscillation)
    - lowered U3 charge pump LP filter cuttoff to 1.6KHz
2020-04-11 renamed
2020-04-12 updated revc
    - Changed ICP header from 2.54 to 1.27
    - Added trim pot connected to ADC IN7 (PA7)
2020-04-12 Finalized RevC
2020-04-22 fixed wiring mistake on trim pot
2020-04-23 RevC spectrum analysis screenshots
2020-04-23 Updated RevD layout
    Additional DG468 SPST switch to shunt FX circuit to GND when bypass enabled.
2020-04-24 Modified RevD design to use IM43 Relay instead of DG468 SW
2020-06-28 added demo video link
2020-06-28 scaled down thumbnail by 50%
2020-06-28 scaled thumbnail by 50%
2020-09-17 changed polarity protection mosfet to schotky diode
